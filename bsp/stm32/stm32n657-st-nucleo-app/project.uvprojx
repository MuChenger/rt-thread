# Keil uVision project project.uvprojx, settings and files
target Template_FSBL (6240000::V6.24::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x30000000-0x3003FFFF) IROM(0x0C000000-0xC07DFFF) IROM2(0x0C07E000-0xC07FFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Template_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32N657xx, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_LIBC
  c misc: -Wno-pointer-bool-conversion -Wno-tautological-compare
  c include: ..\..\..\libcpu\arm\common;board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc;board;..\..\..\components\drivers\include;applications;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\utilities\ulog;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\ipc;packages\CMSIS-Core-latest\Include;.;board\CubeMX_Config\Drivers\CMSIS\Include;..\libraries\HAL_Drivers\drivers;..\libraries\HAL_Drivers;..\..\..\components\drivers\spi;..\..\..\components\drivers\smp_call;board\app;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\cortex-m85;board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy;board\CubeMX_Config\Drivers\CMSIS\Device\ST\STM32N6xx\Include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;board\CubeMX_Config\FSBL\Inc
  asm include: ..\stm32n657-st-nucleo
  memory RVCT4: ROM 0x70100400 size 0x1dfc00
  memory RVCT5: ROM 0xc07e000 size 0x2000
  memory RVCT9: RAM 0x34000000 size 0x100000
  scatter file: .\board\linker_scripts\link_app.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_pwm.c drv_spi.c drv_tim.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_spi.c stm32n6xx_hal_spi_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
    board/CubeMX_Config/FSBL/Src/: stm32n6xx_hal_msp.c
    board/CubeMX_Config/MDK-ARM/: startup_stm32n657xx_fsbl.c
    board/app/: system_stm32n6xx_s.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh.c cmd.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
software components: CMSIS:CORE 5.6.0
