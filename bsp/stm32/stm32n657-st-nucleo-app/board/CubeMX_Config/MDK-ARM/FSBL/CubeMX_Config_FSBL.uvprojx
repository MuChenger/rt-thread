# Keil uVision project CubeMX_Config_FSBL.uvprojx, settings and files
target CubeMX_Config_FSBL (6240000::V6.24::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341BFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: CubeMX_Config_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx
  c include: ../../FSBL/Inc;../../Drivers/STM32N6xx_HAL_Driver/Inc;../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL
    ../../FSBL/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cortex.c stm32n6xx_hal_spi.c stm32n6xx_hal_spi_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
