# Keil uVision project template.uvprojx, settings and files
target Template_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x30000000-0x3003FFFF) IROM(0x0C000000-0xC07DFFF) IROM2(0x0C07E000-0xC07FFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Template_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx
  c misc: -Wno-pointer-bool-conversion -Wno-tautological-compare
  c include: ../../FSBL/Inc;../../../../../../Drivers/BSP/STM32N6xx_Nucleo;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  asm include: ..\stm32n657-st-nucleo
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT5: ROM 0xc07e000 size 0x2000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: .\board\CubeMX_Config\MDK-ARM\FSBL\stm32n657xx_axisram2_fsbl.sct
  group Doc
    ../../: README.md
software components: CMSIS:CORE 5.6.0
