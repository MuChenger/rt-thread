# Keil uVision project project.uvprojx, settings and files
target Template_FSBL (6240000::V6.24::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x30000000-0x3003FFFF) IROM(0x0C000000-0xC07DFFF) IROM2(0x0C07E000-0xC07FFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Template_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32H743xx,USE_HAL_DRIVER
  c include: rt-thread\components\libc\posix\io\eventfd;rt-thread\libcpu\arm\common;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\drivers\smp_call;rt-thread\components\libc\compilers\common\include;board;board\CubeMX_Config\Drivers;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc;rt-thread\include;libraries\HAL_Drivers;rt-thread\components\net\utest;libraries\HAL_Drivers\drivers;rt-thread\components\libc\compilers\common\extension;board\CubeMX_Config\Inc;board\CubeMX_Config\Drivers\CMSIS\Device\ST\STM32N6xx\Include;rt-thread\components\libc\posix\io\poll;board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\phy;.;board\CubeMX_Config\FSBL\Core\Inc;board\CubeMX_Config\Drivers\BSP\STM32N6xx_Nucleo;rt-thread\components\libc\posix\io\epoll;libraries\HAL_Drivers\drivers\config;applications;board\CubeMX_Config\Drivers\CMSIS\Include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;..\project;.\board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc;.\board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy
  asm include: ..\project
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT5: ROM 0xc07e000 size 0x2000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: .\board\CubeMX_Config\FSBL\stm32n657xx_axisram2_fsbl.sct
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c
    ./rt-thread/libcpu/arm/cortex-m7/: context_gcc.S
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    rt-thread/components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group FSBL
    board/CubeMX_Config/FSBL/Core/Src/: sysmem.c stm32n6xx_it.c syscalls.c main.c system_stm32n6xx_fsbl.c stm32n6xx_hal_msp.c
    ./board/CubeMX_Config/FSBL/Core/Startup/: startup_stm32n657xx_fsbl.c
  group HAL
    board/CubeMX_Config/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_icache.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_usart.c stm32n6xx_hal_usart_ex.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_pwr.c stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_exti.c stm32n6xx_hal_rcc.c
    board/CubeMX_Config/Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
software components: CMSIS:CORE 5.6.0
