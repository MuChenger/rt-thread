# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, STM32H743xx, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__, RT_USING_ARMLIBC
  c include: ..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\net\utest;board\CubeMX_Config\Drivers\CMSIS\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;board\CubeMX_Config\FSBL\Core\Inc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;board\CubeMX_Config\Drivers\BSP\STM32N6xx_Nucleo;.;applications;..\..\..\include;..\..\..\components\drivers\phy;..\libraries\HAL_Drivers\drivers\config;board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy;board\CubeMX_Config\Drivers;..\libraries\HAL_Drivers;board\CubeMX_Config\Drivers\CMSIS\Device\ST\STM32N6xx\Include;board\CubeMX_Config\Drivers\STM32N6xx_HAL_Driver\Inc;..\..\..\components\libc\posix\io\eventfd;board\CubeMX_Config\Inc;..\..\..\components\drivers\smp_call;..\libraries\HAL_Drivers\drivers;board;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c
    board/: board.c
  group FSBL
    board/CubeMX_Config/FSBL/Core/Src/: sysmem.c main.c syscalls.c stm32n6xx_hal_msp.c system_stm32n6xx_fsbl.c stm32n6xx_it.c
    board/CubeMX_Config/FSBL/Core/Startup/: startup_stm32n657x0hxq_fsbl.s
  group HAL
    board/CubeMX_Config/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_gpio.c stm32n6xx_hal_exti.c stm32n6xx_hal_icache.c stm32n6xx_hal_cortex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_usart.c stm32n6xx_hal.c stm32n6xx_hal_usart_ex.c
    board/CubeMX_Config/Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
