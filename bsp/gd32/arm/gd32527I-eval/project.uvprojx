# Keil uVision project project.uvprojx, settings and files
target rt-thread (6240000::V6.24::ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, GD32F527, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_LIBC
  c include: packages\LVGL-v8.3.5\src\extra\others\msg;..\..\..\..\components\drivers\spi;packages\LVGL-v8.3.5\src\extra\widgets\colorwheel;packages\LVGL-v8.3.5\demos\keypad_encoder;..\..\..\..\components\libc\posix\io\epoll;packages\xpt2046-latest;packages\LVGL-v8.3.5\src\extra\others\ime;packages\LVGL-v8.3.5\src\core;packages\LVGL-v8.3.5\src\extra\libs\qrcode;packages\LVGL-v8.3.5\src\extra\themes;packages\LVGL-v8.3.5\src\extra\widgets\list;packages\gd32-arm-cmsis-latest\GD32F5xx;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;packages\LVGL-v8.3.5\src\extra\widgets\tabview;packages\LVGL-v8.3.5\src\draw;packages\LVGL-v8.3.5\src\extra\widgets\imgbtn;..\..\..\..\components\drivers\include;applications\porting;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.5\src\extra\others\imgfont;packages\LVGL-v8.3.5\src\extra\themes\basic;packages\LVGL-v8.3.5\src\extra\widgets\meter;packages\LVGL-v8.3.5\src\misc;packages\LVGL-v8.3.5\src\draw\nxp\vglite;packages\LVGL-v8.3.5\src\extra\others\gridnav;packages\LVGL-v8.3.5\src\extra\layouts;packages\LVGL-v8.3.5\src\extra\others;packages\LVGL-v8.3.5\src\extra\themes\mono;packages\LVGL-v8.3.5\demos\music;packages\LVGL-v8.3.5\src\extra\libs\freetype;..\..\..\..\components\legacy;packages\LVGL-v8.3.5\demos\stress;..\..\..\..\libcpu\arm\common;packages\LVGL-v8.3.5\src\extra\widgets\keyboard;packages\LVGL-v8.3.5\src\extra\libs\gif;..\..\..\..\components\drivers\smp_call;packages\LVGL-v8.3.5\src\font;packages\LVGL-v8.3.5\src\extra\libs\sjpg;packages\LVGL-v8.3.5\src\extra\widgets\chart;..\..\..\..\components\utilities\ulog;..\..\..\..\components\finsh;packages\LVGL-v8.3.5\src;packages\LVGL-v8.3.5\src\extra\libs;packages\LVGL-v8.3.5\src\extra\libs\ffmpeg;packages\LVGL-v8.3.5\demos\benchmark;packages\LVGL-v8.3.5\src\extra\widgets\calendar;packages\LVGL-v8.3.5\src\extra\libs\fsdrv;..\..\..\..\components\fal\inc;packages\LVGL-v8.3.5\src\extra\others\snapshot;..\libraries\gd32_drivers;packages\LVGL-v8.3.5\src\hal;..\..\..\..\components\libc\posix\ipc;packages\LVGL-v8.3.5\src\extra\widgets;packages\LVGL-v8.3.5\demos\widgets;packages\LVGL-v8.3.5\src\extra\widgets\led;board;applications\software;applications;packages\LVGL-v8.3.5\demos;packages\LVGL-v8.3.5\src\extra\widgets\span;packages\LVGL-v8.3.5\src\extra\others\fragment;applications\ui;packages\LVGL-v8.3.5\src\draw\nxp\pxp;..\..\..\..\components\drivers\touch;packages\LVGL-v8.3.5\src\draw\arm2d;packages\LVGL-v8.3.5\src\extra\widgets\spinbox;packages\LVGL-v8.3.5\src\extra\widgets\win;packages\LVGL-v8.3.5\demos\music\assets;.;packages\LVGL-v8.3.5\src\draw\swm341_dma2d;packages\LVGL-v8.3.5\src\extra\libs\rlottie;applications\lvgl;..\..\..\..\components\net\utest;..\..\..\..\components\drivers\include;packages\gd32-arm-cmsis-latest\GD32F5xx\GD\GD32F5xx\Include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.5\src\extra\themes\default;packages\LVGL-v8.3.5\src\extra\widgets\msgbox;packages\LVGL-v8.3.5\src\extra;packages\LVGL-v8.3.5\src\extra\widgets\menu;packages\LVGL-v8.3.5\src\extra\others\monkey;packages\LVGL-v8.3.5\src\draw\stm32_dma2d;packages\gd32-arm-series-latest\GD32F5xx\GD32F5xx_standard_peripheral\Include;..\..\..\..\include;packages\LVGL-v8.3.5\src\draw\sdl;packages\LVGL-v8.3.5\src\draw\sw;packages\LVGL-v8.3.5\src\widgets;packages\LVGL-v8.3.5\src\extra\widgets\animimg;packages\LVGL-v8.3.5\src\extra\libs\png;..\..\..\..\components\libc\posix\io\eventfd;packages\LVGL-v8.3.5\src\extra\libs\bmp;..\..\..\..\libcpu\arm\cortex-m33;packages\LVGL-v8.3.5\src\extra\layouts\grid;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\spi\sfud\inc;packages\LVGL-v8.3.5\src\extra\layouts\flex;packages\LVGL-v8.3.5\src\extra\widgets\spinner;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.5\env_support\rt-thread;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\compilers\common\extension;packages\LVGL-v8.3.5\src\extra\widgets\tileview
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../components/drivers/touch/: dev_touch.c
  group Drivers
    board/: board.c fal_sample.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_sdram.c drv_spi.c drv_spi_flash.c drv_usart.c
  group Fal
    ../../../../components/fal/src/: fal_rtt.c fal.c fal_partition.c fal_flash.c
    ../../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c kerrno.c rt_vsnprintf_tiny.c kstring.c kstdio.c
  group Legacy
    ../../../../components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/ARM/: startup_gd32f5xx.s
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/: system_gd32f5xx.c
    packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_dbg.c gd32f5xx_dma.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_gpio.c gd32f5xx_misc.c gd32f5xx_rcu.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_tli.c gd32f5xx_usart.c
  group lvgl
    applications/lvgl/: lv_demo_calendar.c lv_demo.c
  group LVGL
    packages/LVGL-v8.3.5/demos/benchmark/assets/: img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_chroma_keyed.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_argb.c
    packages/LVGL-v8.3.5/demos/music/assets/: img_lv_demo_music_btn_prev.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_btn_loop.c img_lv_demo_music_icon_1.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_logo.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_wave_top_large.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_list_border_large.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_cover_1.c img_lv_demo_music_btn_next.c img_lv_demo_music_list_border.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_cover_3.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_cover_2.c img_lv_demo_music_icon_3.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_slider_knob.c
    packages/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.5/src/misc/: lv_fs.c lv_templ.c lv_utils.c lv_anim.c lv_txt_ap.c lv_style_gen.c lv_bidi.c lv_style.c lv_anim_timeline.c lv_gc.c lv_log.c lv_txt.c lv_timer.c lv_color.c lv_ll.c lv_area.c lv_math.c lv_lru.c lv_mem.c lv_tlsf.c lv_async.c lv_printf.c
    packages/LVGL-v8.3.5/src/draw/: lv_img_decoder.c lv_draw_mask.c lv_draw_img.c lv_draw.c lv_draw_arc.c lv_draw_rect.c lv_draw_layer.c lv_draw_triangle.c lv_draw_line.c lv_draw_transform.c lv_draw_label.c lv_img_cache.c lv_img_buf.c
    packages/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite_rect.c lv_draw_vglite_blend.c lv_vglite_utils.c lv_vglite_buf.c lv_draw_vglite_line.c lv_draw_vglite.c lv_draw_vglite_arc.c
    packages/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_transform.c lv_draw_sw_dither.c lv_draw_sw_letter.c lv_draw_sw.c lv_draw_sw_blend.c lv_draw_sw_layer.c lv_draw_sw_rect.c lv_draw_sw_img.c lv_draw_sw_gradient.c
    packages/LVGL-v8.3.5/src/widgets/: lv_switch.c lv_label.c lv_textarea.c lv_img.c lv_table.c lv_btn.c lv_objx_templ.c lv_canvas.c lv_arc.c lv_dropdown.c lv_line.c lv_roller.c lv_bar.c lv_btnmatrix.c lv_checkbox.c lv_slider.c
    packages/LVGL-v8.3.5/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.5/src/font/: lv_font_montserrat_28_compressed.c lv_font_montserrat_34.c lv_font.c lv_font_montserrat_42.c lv_font_loader.c lv_font_montserrat_40.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_14.c lv_font_montserrat_44.c lv_font_simsun_16_cjk.c lv_font_montserrat_18.c lv_font_fmt_txt.c lv_font_montserrat_20.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_26.c lv_font_montserrat_22.c lv_font_montserrat_28.c lv_font_montserrat_32.c lv_font_montserrat_24.c lv_font_montserrat_38.c lv_font_montserrat_48.c lv_font_montserrat_30.c lv_font_montserrat_12.c lv_font_unscii_8.c lv_font_montserrat_46.c lv_font_unscii_16.c lv_font_montserrat_12_subpx.c lv_font_montserrat_16.c lv_font_montserrat_36.c
    packages/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.5/src/core/: lv_obj_style_gen.c lv_refr.c lv_obj_draw.c lv_obj_class.c lv_obj_scroll.c lv_indev.c lv_obj_pos.c lv_obj.c lv_obj_tree.c lv_indev_scroll.c lv_group.c lv_theme.c lv_event.c lv_obj_style.c lv_disp.c
    packages/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_label.c lv_draw_sdl_arc.c lv_draw_sdl_rect.c lv_draw_sdl_bg.c lv_draw_sdl_stack_blur.c lv_draw_sdl_img.c lv_draw_sdl_texture_cache.c lv_draw_sdl_layer.c lv_draw_sdl.c lv_draw_sdl_composite.c lv_draw_sdl_line.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.5/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.5/src/extra/: lv_extra.c
    packages/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.5/demos/widgets/assets/: img_demo_widgets_avatar.c img_lvgl_logo.c img_clothes.c
    packages/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.5/src/hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
    packages/LVGL-v8.3.5/demos/benchmark/: lv_demo_benchmark.c
    packages/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.3.5/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.5/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.5/demos/music/: lv_demo_music_list.c lv_demo_music.c lv_demo_music_main.c
    packages/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.5/demos/stress/: lv_demo_stress.c
    packages/LVGL-v8.3.5/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.5/demos/widgets/: lv_demo_widgets.c
    packages/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
  group LVGL-demo
    packages/lv_music_demo-v0.3.2/assets/: img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_slider_knob.c
    packages/lv_music_demo-v0.3.2/: lv_demo_rtt_music_list.c lv_demo_rtt_music.c lv_demo_rtt_music_main.c
  group LVGL-port
    packages/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.c
  group porting
    applications/porting/: lv_port_disp.c lv_port_indev.c
  group software
    applications/software/: lcd_font.c exmc_sdram.c touch_xpt2046.c gd32f527i_lcd_eval.c
  group ui
    applications/ui/: images.c ui.c screens.c styles.c
  group Utilities
    ../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../components/utilities/ulog/: ulog.c
  group xpt2046_touch
    packages/xpt2046-latest/: drv_xpt2046.c
software components: CMSIS:CORE 5.6.0
