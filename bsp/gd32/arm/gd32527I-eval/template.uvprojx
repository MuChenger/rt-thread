# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: .\packages\LVGL-v8.3.11
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.6.0
